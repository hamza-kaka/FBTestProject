# Keil uVision project FullBridge.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: MKV58F1M0VLQ24 NXP
  pack: NXP.MKV58F24_DFP.12.1.0
  cpu: IRAM(0x18000000,0x1000) IRAM2(0x20000000,0x020000) IROM(0x10000000,0x100000) XRAM(0x00000000,0x010000) XRAM2(0x2f000000,0x010000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: test project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: DEBUG, CPU_MKV58F1M0VLQ24, TWR_KV58F220M, TOWER, SERIAL_PORT_TYPE_UART=1
  c include: ..\board;..\components\uart;..\components\serial_manager;..\components\lists;..\Include;..\devices\MKV58F24;..\devices\MKV58F24\drivers;..\devices\MKV58F24\utilities\str;..\devices\MKV58F24\utilities\debug_console;..\..\test project
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT6: RAM 0x0 size 0x10000
  memory RVCT7: RAM 0x2f000000 size 0x10000
  memory RVCT9: RAM 0x18000000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\devices\MKV58F24\arm\MKV58F1M0xxx24_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group main
    ../: main.c UserConfig.h
  group board
    ../board/: clock_config.c clock_config.h pin_mux.c pin_mux.h
  group device
    ../devices/MKV58F24/: fsl_device_registers.h MKV58F24.h MKV58F24_features.h system_MKV58F24.c system_MKV58F24.h
  group utilities
    ../devices/MKV58F24/utilities/: fsl_assert.c
    ../devices/MKV58F24/utilities/str/: fsl_str.c fsl_str.h
    ../devices/MKV58F24/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group components
    ../components/uart/: uart.h uart_adapter.c
    ../components/lists/: generic_list.c generic_list.h
    ../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group startup
    ../devices/MKV58F24/arm/: startup_MKV58F24.s
  group CMSIS
    ../Include/: arm_common_tables.h arm_const_structs.h arm_math.h mpu_armv7.h mpu_armv8.h core_cm7.h core_armv8mbl.h core_armv8mml.h core_armv81mml.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h
  group docs
    ../chashmaTemp/: reliability tests.txt
  group drivers
    ../devices/MKV58F24/drivers/: fsl_adc16.c fsl_adc16.h fsl_aoi.c fsl_aoi.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_enc.c fsl_enc.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flash.h fsl_flexbus.c fsl_flexbus.h fsl_flexcan.c fsl_flexcan.h fsl_flexcan_edma.c fsl_flexcan_edma.h fsl_ftfx_adapter.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_features.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_ftfx_utilities.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_hsadc.c fsl_hsadc.h fsl_i2c.c fsl_i2c.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_pdb.c fsl_pdb.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_pwm.c fsl_pwm.h fsl_rcm.c fsl_rcm.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_sysmpu.c fsl_sysmpu.h fsl_trng.c fsl_trng.h fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h fsl_xbarb.c fsl_xbarb.h
